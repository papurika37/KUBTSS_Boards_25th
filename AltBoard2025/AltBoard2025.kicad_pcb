# Repository papurika37/KUBTSS_Boards_25th

File README.md:

# KUBTSS_Boards_25th
KUBTSS Avionics 25th designed by pprk

## 右矢印（->）について / About the Arrow Operators

このリポジトリに表示されている右矢印（`->`）は、C++言語のアロー演算子です。
これは `esp32_ble_connector/esp32_ble_connector.ino` ファイル内で使用されており、
ポインタを通してオブジェクトのメンバ関数やメンバ変数にアクセスするために使用されます。

例：
- `pCharacteristic -> addDescriptor()` - pCharacteristicポインタのaddDescriptorメソッドを呼び出し
- `pService -> start()` - pServiceポインタのstartメソッドを呼び出し

The right arrows (`->`) displayed in this repository are C++ arrow operators.
They are used in the `esp32_ble_connector/esp32_ble_connector.ino` file to access 
member functions and variables of objects through pointers.

## KiCad design AltBoard2025/AltBoard2025.kicad_pcb

Parts:
C1: 10u; C_0603_1608Metric
C2, C3, C4, C5, C6: 0.1u; C_0603_1608Metric
D1, D2: RB160M; D_SOD-123
D3: CAN; LED_0603_1608Metric
D4: ERR; LED_0603_1608Metric
D5: CON; LED_0603_1608Metric
J1, J2: RJ25; RJ25_Wayconn_MJEA-660X1_Horizontal
J3: ICSP; PinSocket_1x04_P2.54mm_Vertical
JP1: CAN; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1: 120; R_0603_1608Metric
R2, R6: 10k; R_0603_1608Metric
R3, R4, R5: 1k; R_0603_1608Metric
SW1: RESET; SW_SPST_PTS810
U1: MCP25625-x-SS; SSOP-28_5.3x10.2mm_P0.65mm
U2: ATmega328P-A; TQFP-32_7x7mm_P0.8mm
U3: R-78E5.0-0.5; Converter_DCDC_RECOM_R-78E-0.5_THT
U4: DFROBOT_SEN0001_v5
Y1, Y2: 16MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
+5V: C2.1, C3.2, C4.2, C5.1, D2.2 (A), D5.2 (A), R2.1, R6.1, U1.1 (VIO), U1.19 (VDD), U1.27 (VDDA), U2.4 (VCC), U2.18 (AVCC), U3.3 (OUT), U4.1 (vcc)
CANH: J1.4, J2.4, R1.1, U1.4 (CANH)
CANL: J1.3, J2.3, JP1.1 (A), U1.3 (CANL)
CS: U1.17 (~CS), U2.14 (PB2)
ECHO: U2.1 (PD3), U4.4 (ECHO)
ERR: D4.2 (A), U2.10 (PD6)
GND: C1.2, C2.2, C3.1, C4.1, C5.2, C6.1, J1.2, J2.2, R3.2, R4.2, R5.2, SW1.2, U1.5 (STBY), U1.10 (GND), U1.26 (VSS), U2.5 (GND), U2.21 (GND), U3.2 (GND), U4.2 (GND), Y1.2, Y2.2
INT: U1.13 (~INT), U2.32 (PD2)
MISO: J3.2, U1.16 (SO), U2.16 (PB4)
MOSI: J3.1, U1.15 (SI), U2.15 (PB3)
unnamed: D1.2 (A), J1.5, J2.5
unnamed: C1.1, D1.1 (K), D2.1 (K), U3.1 (IN)
unnamed: D3.1 (K), R3.1
unnamed: D4.1 (K), R4.1
unnamed: D5.1 (K), R5.1
unnamed: JP1.2 (B), R1.2
unnamed: U1.9 (OSC1), Y1.1
unnamed: U1.8 (OSC2), Y1.3
unnamed: U1.21 (RxCAN), U1.28 (RXD)
unnamed: U1.20 (TxCAN), U1.24 (TXD)
unnamed: R2.2, U1.18 (~RESET)
unnamed: C6.2, U2.20 (AREF)
unnamed: U2.7 (XTAL1/PB6), Y2.3
unnamed: U2.8 (XTAL2/PB7), Y2.1
RST: J3.4, R6.2, SW1.1, U2.29 (~RESET/PC6)
RX: U2.31 (PD1), U4.8 (RXD)
SCLK: D3.2 (A), J3.3, U1.14 (SCK), U2.17 (PB5)
TRIG: U2.2 (PD4), U4.6 (COMP/TRIG)
TX: U2.30 (PD0), U4.9 (TXD)

Notes on the sheet:
パルスとUARTで距離、温度を測定
データシート
のSerial Modeを参照
超音波高度計(max800cm)と温度センサーを搭載 機体裏側はあまり気候の影響を受けず温度測定できる

Board: 2 copper layers, 30.5 x 35.5 mm, 28 parts (10 on the bottom side), 29 nets.

## Commit log

2025-08-20 KUBTSS Avio
2025-08-20 Initial plan
2025-08-20 Add documentation explaining C++ arrow operators (right arrows) in Japanese
2025-08-20 Avio
2025-08-20 null
